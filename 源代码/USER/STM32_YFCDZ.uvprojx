# Keil uVision project STM32_YFCDZ.uvprojx, settings and files
target YFCDZ (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\Gizwits;..\Utils;..\CORE;..\HARDWARE\BEEP;..\HARDWARE\DS18B20;..\HARDWARE\JDQ;..\HARDWARE\KEY;..\HARDWARE\MODBULES;..\HARDWARE\OLED;..\HARDWARE\TDS;..\SYSTEM\ADC;..\SYSTEM\DELAY;..\SYSTEM\FLASH;..\SYSTEM\SYS;..\SYSTEM\TIMER;..\SYSTEM\USART;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\src;..\STM32F10x_FWLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ../Utils/: common.c dataPointTools.c ringbuffer.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/JDQ/: jdq.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MODBULES/: modules.c
    ../HARDWARE/OLED/: oled.c
  group SYSTEM
    ../SYSTEM/ADC/: adc.c
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/FLASH/: Flash.c Flash.h
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/TIMER/: timer.c timer.h
    ../SYSTEM/USART/: usart2.c usart2.h usart3.h usart3.c
    ./: mimo_token.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
